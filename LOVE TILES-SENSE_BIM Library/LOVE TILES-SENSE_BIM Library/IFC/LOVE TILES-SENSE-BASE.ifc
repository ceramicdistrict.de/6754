Properties of the parts of a building model (IFC4), part 2 of 2

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-WHITE, Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-WHITE:129182
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-WHITE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-IN&OUT RECTFIED-WHITE; Publication date: 01/2025; Reference: 615.0063.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-WHITE; Type Id: 131613

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE, Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE:122883
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 615.0062.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1.0005 m2; Elevation at Bottom: -8 mm; Perimeter: 4001 mm; Thickness: 8 mm; Volume: 0.008004 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; Type Id: 124685

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY, Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY:128027
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; Publication date: 01/2025; Reference: 615.0062.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1.0005 m2; Elevation at Bottom: -8 mm; Perimeter: 4001 mm; Thickness: 8 mm; Volume: 0.008004 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; Type Id: 128978

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY, Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY:129147
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 615.0062.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1.0005 m2; Elevation at Bottom: -8 mm; Perimeter: 4001 mm; Thickness: 8 mm; Volume: 0.008004 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; Type Id: 130820

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE, Floor:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE:129196
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; Publication date: 01/2025; Reference: 615.0062.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1.0005 m2; Elevation at Bottom: -8 mm; Perimeter: 4001 mm; Thickness: 8 mm; Volume: 0.008004 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; Type Id: 131709

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE, Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE:122727
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 608.0022.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-BEIGE; Type Id: 120841

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-GREY, Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-GREY:128006
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE80x80-IN&OUT RECTFIED-GREY; Publication date: 01/2025; Reference: 608.0022.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-GREY; Type Id: 128202

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY, Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY:129126
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 608.0022.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-LIGHT GREY; Type Id: 130494

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-WHITE, Floor:LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-WHITE:129175
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-WHITE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE80x80-IN&OUT RECTFIED-WHITE; Publication date: 01/2025; Reference: 608.0022.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-80x80-IN&OUT RECTIFIED-WHITE; Type Id: 131566

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE, Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE:120090
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 608.0021.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Area: 1 m2; Elevation at Bottom: -9 mm; Elevation at Top: 0 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; Type Id: 124214

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY, Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY:127991
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; Publication date: 01/2025; Reference: 608.0021.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; Type Id: 128931

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY, Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY:129111
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 608.0021.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; Type Id: 130588

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE, Floor:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE:129160
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; Publication date: 01/2025; Reference: 608.0021.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; Family and Type: Floor: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; Type Id: 132095
