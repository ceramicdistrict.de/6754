Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: cce211e1-29c3-4a6e-bc02-b456555b0d40, NumberOfSaves: 170], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: LOVE TILES-SENSE-BASE.ifc
Time: 2025-04-01T11:52:27
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - Library Version: V01
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 01/2025

# IfcBuilding
Text - Library Version: V01
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 01/2025

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1604
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-BEIGE, Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-BEIGE:124903
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.35 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x100-MATT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 635.0180.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-BEIGE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-BEIGE; Type Id: 122124

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-GREY, Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-GREY:127656
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.35 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x100-MATT RECTIFIED-GREY; Publication date: 01/2025; Reference: 635.0180.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-GREY; Type Id: 127783

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY, Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY:129153
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.35 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 635.0180.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-LIGHT GREY; Type Id: 130879

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-WHITE, Basic Wall:LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-WHITE:129155
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.35 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x100-MATT RECTIFIED-WHITE; Publication date: 01/2025; Reference: 635.0180.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-WHITE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-35x100-MATT RECTIFIED-WHITE; Type Id: 131095

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-BEIGE, Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-BEIGE:126834
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x70-MATT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 635.0180.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-BEIGE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-BEIGE; Type Id: 126877

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-GREY, Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-GREY:127657
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x70-MATT RECTIFIED-GREY; Publication date: 01/2025; Reference: 635.0180.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-GREY; Type Id: 127886

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY, Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY:129154
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 635.0180.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-LIGHT GREY; Type Id: 130967

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-WHITE, Basic Wall:LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-WHITE:129156
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-35x70-MATT RECTIFIED-WHITE; Publication date: 01/2025; Reference: 635.0180.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-WHITE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-35x70-MATT RECTIFIED-WHITE; Type Id: 131031

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE, Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE:121983
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 608.0021.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-BEIGE; Type Id: 126674

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY, Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY:127996
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; Publication date: 01/2025; Reference: 608.0021.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-GREY; Type Id: 129435

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY, Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY:129116
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 608.0021.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-LIGHT GREY; Type Id: 132196

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE, Basic Wall:LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE:129165
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; Publication date: 01/2025; Reference: 608.0021.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-60x60-TOUCH RECTIFIED-WHITE; Type Id: 131773

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE, Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE:114348
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Absorptance: 0.1; Roughness: 1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Width: 9 mm; Wrapping at Inserts: Do not wrap
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 608.0021.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.009 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-BEIGE; Type Id: 114736

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY, Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY:127988
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; Publication date: 01/2025; Reference: 608.0021.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.009 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-GREY; Type Id: 129355

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY, Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY:129108
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 608.0021.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.009 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-LIGHT GREY; Type Id: 130652

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE, Basic Wall:LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE:129157
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.64 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; Publication date: 01/2025; Reference: 608.0021.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.009 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-80x80-TOUCH RECTIFIED-WHITE; Type Id: 132029

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE, Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE:122720
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 1 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 678.0078.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-BEIGE; Type Id: 114640

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-GREY, Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-GREY:127999
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 1 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-100x100-IN&OUT RECTFIED-GREY; Publication date: 01/2025; Reference: 678.0078.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-GREY; Type Id: 128234

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY, Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY:129119
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 1 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 678.0078.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-LIGHT GREY; Type Id: 130541

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-WHITE, Floor:LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-WHITE:129168
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-WHITE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 1 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 9 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-100x100-IN&OUT RECTFIED-WHITE; Publication date: 01/2025; Reference: 678.0078.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9 mm; Perimeter: 4000 mm; Thickness: 9 mm; Volume: 0.009 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-100x100-IN&OUT RECTIFIED-WHITE; Type Id: 131519

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE, Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE:122741
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.18 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 631.0031.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-BEIGE; Type Id: 122752

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-GREY, Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-GREY:128020
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.18 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-30x60-IN&OUT RECTFIED-GREY; Publication date: 01/2025; Reference: 631.0031.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-GREY; Type Id: 128041

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY, Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY:129140
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.18 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 631.0031.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-LIGHT GREY; Type Id: 130151

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-WHITE, Floor:LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-WHITE:129189
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-WHITE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.18 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-30x60-IN&OUT RECTFIED-WHITE; Publication date: 01/2025; Reference: 631.0031.001; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BASE-30x60-IN&OUT RECTIFIED-WHITE; Type Id: 131660

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE, Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE:122734
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 615.0063.002; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-BEIGE; Type Id: 122075

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-GREY, Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-GREY:128013
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-IN&OUT RECTFIED-GREY; Publication date: 01/2025; Reference: 615.0063.003; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-GREY; Type Id: 128170

# IfcCovering: Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY, Floor:LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY:129133
In: Level 1
Type - PredefinedType: FLOORING; Material: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.36 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Default Thickness: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 615.0063.047; Technical features: www.lovetiles.com/mediafile/8053; Type Name: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Floors; Family Name: Floor
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -8 mm; Perimeter: 4000 mm; Thickness: 8 mm; Volume: 0.008 m3
Other - Family: Floor; Family and Type: Floor: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BASE-60x60-IN&OUT RECTIFIED-LIGHT GREY; Type Id: 130230
