Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 9933c3cc-be4f-40b0-bf95-de1d02d9f533, NumberOfSaves: 185], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: LOVE TILES-SENSE-BITMAP DECORATION.ifc
Time: 2025-04-01T11:52:27
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - Library Version: V01
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 01/2025

# IfcBuilding
Text - Library Version: V01
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 01/2025

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1604
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE, Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE:124903
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Absorptance: 0.1; Roughness: 1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Width: 8 mm; Wrapping at Inserts: Do not wrap
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE; Publication date: 01/2025; Reference: 664.0176.008; Type Name: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE; Type: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-BLUE; Type Id: 122124

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN, Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN:127656
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN; Publication date: 01/2025; Reference: 664.0176.007; Type Name: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN; Type: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-GREEN; Type Id: 127783

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED, Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED:129153
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED; Publication date: 01/2025; Reference: 664.0176.024; Type Name: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED; Type: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-RED; Type Id: 130879

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE, Basic Wall:LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE:129155
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE; Publication date: 01/2025; Reference: 664.0176.003; Type Name: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.008 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BITMAP DECORATION-35x70-MATT RECTIFIED-WHITE; Type Id: 131095
