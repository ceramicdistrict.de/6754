Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 70968663-5117-4282-8f7e-a3fac073a77d, NumberOfSaves: 190], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: LOVE TILES-SENSE-BOTANIC DECORATION.ifc
Time: 2025-04-01T11:52:27
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - Library Version: V01
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 01/2025

# IfcBuilding
Text - Library Version: V01
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 01/2025

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1604
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE, Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE:124903
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Absorptance: 0.1; Roughness: 1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Width: 8.7 mm; Wrapping at Inserts: Do not wrap
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE; Publication date: 01/2025; Reference: 629.0161.002; Type Name: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0087 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE; Type: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-BEIGE; Type Id: 122124

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY, Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY:127656
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8.7 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY; Publication date: 01/2025; Reference: 629.0161.003; Type Name: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0087 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY; Type: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-GREY; Type Id: 127783

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY, Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY:129153
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8.7 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY; Publication date: 01/2025; Reference: 629.0161.047; Type Name: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0087 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY; Type: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-LIGHT GREY; Type Id: 130879

# IfcCovering: Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE, Basic Wall:LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE:129155
In: Level 1
Type - PredefinedType: CLADDING
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Analysis Results - Area per Piece: 0.245 m2
Type - Graphics - Coarse Scale Fill Color: 0
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 8.7 mm
Type - Identity Data - Description: Sense harks back to the epic elegance of stone and nature itself. Arsel stone is a famous limestone of Greek origin, characterized by a very light and uniform beige colour. The design of Sense was based on this limestone, which is very resistant and has unique characteristics in terms of texture. Produced in coloured body porcelain stoneware, Sense is a collection that was born on the pavement and evolved into cladding. Its resistance to wear, durability and consistent resistance to frost make this stone the queen of building materials.; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE; Publication date: 01/2025; Reference: 629.0161.001; Type Name: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE; URL: https://lovetiles.com/pt/produtos/sense; Version: V01
Type - Other - Category: Walls; Family Name: Basic Wall
Material: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE
Cross-Section Definition - Cross-Section: Vertical
Constraints - Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0087 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE; Type: LOVE TILES-SENSE-BOTANIC DECORATION-35x70-MATT RECTIFIED-WHITE; Type Id: 131095
