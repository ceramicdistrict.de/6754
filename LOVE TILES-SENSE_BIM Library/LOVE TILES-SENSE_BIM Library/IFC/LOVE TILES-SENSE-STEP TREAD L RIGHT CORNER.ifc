Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 49b57ced-fc48-4317-8a2d-60f358718480, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project1.ifc
Time: 2025-04-01T11:57:39
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: LOVE TILES-SENSE-STEP TREAD L RIGHT CORNER:30x80-TOUCH RECTIFIED-BEIGE, LOVE TILES-SENSE-STEP TREAD L RIGHT CORNER:30x80-TOUCH RECTIFIED-BEIGE:8545
In: Level 1
Type - PredefinedType: FLOORING
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com
Type - Constraints - Default Elevation: 0 mm
Type - Materials and Finishes - Material: LOVE TILES-SENSE-STEP-30X80-TOUCH RECTIFIED-BEIGE
Type - Dimensions - Length: 300 mm; Thickness: 9 mm; Width: 802 mm
Type - Identity Data - Assembly Code: C3020; Manufacturer: LOVE TILES; Manufacturer URL: https://lovetiles.com/pt; Model: SENSE; Publication date: 01/2025; Type Comments: Step Tread L Right Corner; Type Name: 30x80-TOUCH RECTIFIED-BEIGE; URL: https://lovetiles.com/en/products/sense; Version: V01
Type - Other - Category: Generic Models; Family Name: LOVE TILES-SENSE-STEP TREAD L RIGHT CORNER
Classification: C3020 Uniformat (Uniformat); Material: LOVE TILES-SENSE-STEP-30X80-TOUCH RECTIFIED-BEIGE
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Phasing - Phase Created: New Construction
Dimensions - Area: 0.300696 m2; Volume: 0.00268476 m3
Other - Family: LOVE TILES-SENSE-STEP TREAD L RIGHT CORNER; Family and Type: LOVE TILES-SENSE-STEP TREAD L RIGHT CORNER: 30x80-TOUCH RECTIFIED-BEIGE; Type: 30x80-TOUCH RECTIFIED-BEIGE; Type Id: 8479
